# Repository armgit5/sevenSegmentDisplay

File README.md:

# sevenSegmentDisplay

seven segment display board.

## KiCad design sevenSegmentDisplayBoard.kicad_pcb

Parts:
P1: CONN_01X05; Pin_Header_Straight_1x05
R1, R2, R3, R4, R5, R6, R7, R8: 220 Ohm; Resistor_Horizontal_RM10mm
S1: 7SEGM; 7SegmentLED_LTS6760_LTS6780
U1: 74HC595; DIP-16_W7.62mm

Connections:
/CLOCK: P1.4, U1.12 (RCLK)
/DATA: P1.5, U1.11 (SRCLK)
/LATCH: P1.3, U1.14 (SER)
/sg0: R8.1, U1.15 (QA)
/sg1: R7.1, U1.1 (QB)
/sg2: R6.1, U1.2 (QC)
/sg3: R5.1, U1.3 (QD)
/sg4: R4.1, U1.4 (QE)
/sg5: R3.1, U1.5 (QF)
/sg6: R2.1, U1.6 (QG)
/sg7: R1.1, U1.7 (QH)
GND: P1.2, U1.8 (GND), U1.13 (G)
unnamed: R1.2, S1.5 (SegmDP)
unnamed: R2.2, S1.10 (Segm_G)
unnamed: R3.2, S1.9 (Segm_F)
unnamed: R4.2, S1.1 (Segm_E)
unnamed: R5.2, S1.2 (Segm_D)
unnamed: R6.2, S1.4 (Segm_C)
unnamed: R7.2, S1.6 (Segm_B)
unnamed: R8.2, S1.7 (Segm_A)
VCC: P1.1, S1.3 (K), S1.8 (K), U1.10 (SRCLR), U1.16 (VCC)

Board: 2 copper layers, 58.4 x 41.9 mm, 11 parts (0 on the bottom side), 21 nets.
